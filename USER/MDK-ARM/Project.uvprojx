# Keil uVision project Project.uvprojx, settings and files
target STM32746G_DISCOVERY (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746G_BSP +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCO,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../Drivers/CMSIS/Include;../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../Drivers/STM32F7xx_HAL_Driver/Inc;../../Drivers/BSP/STM32746G-Discovery;../../Drivers/BSP/Components/Common;../../Utilities/Log;../../Utilities/Fonts;../../Utilities/CPU;../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../Middlewares/Third_Party/FreeRTOS/Source/include;../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../Middlewares/Third_Party/FatFs/src;../../Middlewares/Third_Party/FatFs/src/drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f746xx.s
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/Components
    ../../drivers/BSP/Components/ft5336/: ft5336.c
    ../../drivers/BSP/Components/ov9655/: ov9655.c
    ../../drivers/BSP/Components/wm8994/: wm8994.c
  group Example/User
    ../Src/: sdram.c eeprom.c lcd.c audio_loopback.c sdram_dma.c audio_play.c touchscreen.c audio_rec.c main.c qspi.c camera.c stm32f7xx_it.c log.c sd.c rtos_main_suspend.c
    ../Src/usart/: usart.c
  group Drivers/BSP/STM32746G_DISCOVERY
    ../../drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_audio.c stm32746g_discovery_camera.c stm32746g_discovery_eeprom.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dma.c stm32f7xx_hal_i2s.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_sai_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_flash.c stm32f7xx_hal_sai.c stm32f7xx_hal_uart.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_tim.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_nor.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_sram.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_sd.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rcc_ex.c
  group Utilities
    ../../Utilities/Log/: lcd_log.c
    ../../Utilities/CPU/: cpu_utils.c
  group freeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freertos/portable
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Fatfs/options
    ../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Fatfs/
    ../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio_dma_rtos_template.c
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
software components: CMSIS:CORE 4.3.0
